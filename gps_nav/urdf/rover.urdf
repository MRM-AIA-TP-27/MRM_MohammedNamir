Commit message: Updated URDF

File: gps_nav/urdf/rover.urdf (robot description, URDF)
Before this commit: robot basic_rover, 15 links, 14 joints
Joints:
- joint depth_camera_optical_joint: origin xyz=0.25 0 0.125 -> xyz=0 0 0 rpy=-1.5707 0 -1.5707
